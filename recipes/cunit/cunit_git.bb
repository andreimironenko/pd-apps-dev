require ${OEBASE}/pd-apps/recipes/cunit/cunit.inc

inherit srctree gitver

                 
S = ${FILE_DIRNAME}/${PN}-git
SRCREV = "${GITVER}"
PV = "${GITVER}"










 
